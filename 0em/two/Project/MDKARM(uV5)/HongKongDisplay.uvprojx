# Keil uVision project HongKongDisplay.uvprojx, settings and files
target SanFeng (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SanFengDisplay +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User;..\..\HARDWARE\BEEP;..\..\HARDWARE\COMMENT;..\..\HARDWARE\FLASH;..\..\HARDWARE\KEY;..\..\HARDWARE\REMOTE;..\..\HARDWARE\TIM_PWM;..\..\HARDWARE\TIMER;..\..\HARDWARE\USART1;..\..\HARDWARE\USART2;..\..\HARDWARE\USART3;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\HARDWARE\STEP_DRIVER;..\..\HARDWARE\RANGE_SENSOR;..\..\HARDWARE\AS608;..\..\HARDWARE\USER_IIC;..\..\HARDWARE\MACHINE;..\..\HARDWARE\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group User
    ../../User/: main.c stm32f10x_it.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../../HARDWARE/AS608/: as608.c
    ../../HARDWARE/BEEP/: beep.c
    ../../HARDWARE/COMMENT/: SysComment.c
    ../../HARDWARE/FLASH/: San_Flash.c
    ../../HARDWARE/KEY/: key.c
    ../../HARDWARE/REMOTE/: remote.c
    ../../HARDWARE/TIM_PWM/: pwm.c
    ../../HARDWARE/TIMER/: timer.c
    ../../HARDWARE/USART1/: usart1.c
    ../../HARDWARE/USART2/: usart2.c
    ../../HARDWARE/USART3/: usart3.c
    ../../HARDWARE/RANGE_SENSOR/: range_sensor.c
    ../../HARDWARE/STEP_DRIVER/: step_driver.c
    ../../HARDWARE/USER_IIC/: useri2c.c
    ../../HARDWARE/LED/: led.c
  group Sys
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
